1 0.0560000 0.000000 3.39000 0.000000 81
295.000 303.000 0
2.00000 0.400000 0.228000 0.0440000 0.0330000 0.0170000
20.0000 0.000000 0.000000 2.00000 2.00000 10 10
4 1 3
0 0 0 0.000000 0 0.000000
