   1 0.056 0.0 3.39 0.0 81
   295. 303. 0
   2.0 0.4 0.228 0.044 0.033 0.017
   20.0   0. 0. 2. 2. 20 10
   6 1 3
   0 0 0 0 0 0
