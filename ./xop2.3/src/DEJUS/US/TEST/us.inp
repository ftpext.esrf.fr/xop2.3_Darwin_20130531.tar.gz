APS Undulator A, Beam Parameters from SPIE vol. 2856/16-25
    7.00  100.00                               Ring-Energy Current
   0.300   0.060  0.0250  0.0053               Sx Sy Sxp Syp
    3.30      70   0.000   2.760               Period N Kx Ky
    1000.0   50000.0    5000                   Emin Emax Ne
  30.000   0.000   0.000   2.500   1.000    25    10   D Xpc Ypc Xps Yps Nxp Nyp
       2       4       0                       Mode Method Iharm
       0       0     0.0      64     8.0     0 Nphi Nalpha Dalpha2 Nomega Domega Nsigma
foreground
