Data for Wiggler A at APS
     7.00       100.0			      RING-ENERGY CURRENT
     8.50        28.0     7.937		      PERIOD N K
     100.0    100000.0    1000		      EMIN EMAX NE
       30.0    0.00        0.00		      D XPC YPC
