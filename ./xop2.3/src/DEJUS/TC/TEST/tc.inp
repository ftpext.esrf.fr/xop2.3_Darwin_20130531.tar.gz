APS Undulator A, Beam Parameters spring-96 (Ref. SPIE vol. 2856/16-25)
    7.00  100.00 0.00100                       ring-energy(GeV) current(mA) sige
   0.300   0.060  0.0250  0.0053               sx(mm) sy(mm) sx1(mrad) sy1(mrad)
    3.30      70                               period(cm) N
    2900.0   13500.0      20                   emin emax ne
       1       5       2                       hmin hmax hstep
       0       0       1     100               helical method print_k neks
background
