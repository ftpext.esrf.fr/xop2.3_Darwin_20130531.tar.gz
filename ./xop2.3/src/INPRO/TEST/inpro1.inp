/scisoft/XRayOptics/xop2.1/data/inpro/
+1
500.000
       1
EV
      8000.00
1
1
1
0.00000
300.000
inpro.dat
1
100
