xcrystal1.bragg
       0
       0
0.700000
0.00000
 3
8000.000000000
1
-100.000
100.000
200
