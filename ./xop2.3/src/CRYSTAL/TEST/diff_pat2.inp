xcrystal2.bragg
       1
       0
0.400000
2.00000
 3
18000.000000000
2
-1.00000
1.00000
200
